#pragma once

#include "light/Layer.h"
#include "core/color.h"

namespace mm {

// Atmospheric lava-lamp: three slow blobs whose summed field is mapped
// through a black → red → orange → yellow → white palette.
// Distinct from MetaballsEffect (which is fast, HSV-coloured).
class LavaLampEffect : public EffectBase {
public:
    static constexpr uint8_t NUM_BLOBS = 3;

    uint8_t bpm = 8;
    uint8_t radius = 36;
    uint8_t intensity = 200;

    void onBuildControls() override {
        controls_.addUint8("bpm", bpm, 1, 255);
        controls_.addUint8("radius", radius, 8, 255);
        controls_.addUint8("intensity", intensity, 1, 255);
    }

    void loop() override {
        uint8_t* buf = buffer();
        lengthType w = width();
        lengthType h = height();
        uint8_t cpl = channelsPerLight();
        if (w <= 0 || h <= 0) return;

        uint32_t now = elapsed();
        uint32_t dt = now - lastElapsed_;
        lastElapsed_ = now;
        phase_ += static_cast<uint64_t>(dt) * bpm * 256 / 60000;
        uint8_t t = static_cast<uint8_t>(phase_);

        int16_t bx[NUM_BLOBS] = {};
        int16_t by[NUM_BLOBS] = {};
        static constexpr uint8_t SPEED_MUL[NUM_BLOBS] = { 1, 2, 1 };
        static constexpr uint8_t PHASE_X[NUM_BLOBS]   = { 0, 80, 160 };
        static constexpr uint8_t PHASE_Y[NUM_BLOBS]   = { 64, 200, 100 };
        for (uint8_t b = 0; b < NUM_BLOBS; b++) {
            uint8_t tb = static_cast<uint8_t>(t * SPEED_MUL[b]);
            bx[b] = static_cast<int16_t>((sin8(static_cast<uint8_t>(tb + PHASE_X[b])) * w) >> 8);
            by[b] = static_cast<int16_t>((sin8(static_cast<uint8_t>(tb + PHASE_Y[b])) * h) >> 8);
        }
        int32_t r2 = static_cast<int32_t>(radius) * radius;

        for (lengthType y = 0; y < h; y++) {
            uint8_t* row = buf + static_cast<size_t>(y) * static_cast<size_t>(w) * cpl;
            for (lengthType x = 0; x < w; x++) {
                uint32_t field = 0;
                for (uint8_t b = 0; b < NUM_BLOBS; b++) {
                    int32_t dx = static_cast<int32_t>(x) - bx[b];
                    int32_t dy = static_cast<int32_t>(y) - by[b];
                    int32_t d2 = dx * dx + dy * dy + 1;
                    field += static_cast<uint32_t>((r2 * 64) / d2);
                }
                uint32_t scaled = (field * intensity) >> 8;
                uint8_t idx = scaled > 255 ? 255 : static_cast<uint8_t>(scaled);
                const RGB& c = palette_[idx];
                if (cpl >= 1) row[0] = c.r;
                if (cpl >= 2) row[1] = c.g;
                if (cpl >= 3) row[2] = c.b;
                row += cpl;
            }
        }
    }

private:
    uint64_t phase_ = 0;
    uint32_t lastElapsed_ = 0;

    // Lava palette: black → deep red → red → orange → yellow → near-white.
    // 256 RGB entries (768 bytes) — stored in flash.
    static constexpr RGB palette_[256] = {
        {0,0,0}, {4,0,0}, {8,0,0}, {12,0,0}, {16,0,0}, {20,0,0}, {24,0,0}, {28,0,0},
        {32,0,0}, {36,0,0}, {40,0,0}, {44,0,0}, {48,0,0}, {52,0,0}, {56,0,0}, {60,0,0},
        {64,0,0}, {68,0,0}, {72,0,0}, {76,0,0}, {80,0,0}, {84,0,0}, {88,0,0}, {92,0,0},
        {96,0,0}, {100,0,0}, {104,0,0}, {108,0,0}, {112,0,0}, {116,0,0}, {120,0,0}, {124,0,0},
        {128,0,0}, {132,0,0}, {136,0,0}, {140,0,0}, {144,0,0}, {148,0,0}, {152,0,0}, {156,0,0},
        {160,0,0}, {164,0,0}, {168,0,0}, {172,0,0}, {176,0,0}, {180,0,0}, {184,0,0}, {188,0,0},
        {192,0,0}, {196,0,0}, {200,0,0}, {204,0,0}, {208,0,0}, {212,0,0}, {216,0,0}, {220,0,0},
        {224,0,0}, {228,0,0}, {232,0,0}, {236,0,0}, {240,0,0}, {244,0,0}, {248,0,0}, {252,0,0},
        {255,0,0}, {255,0,0}, {255,0,0}, {255,0,0}, {255,0,0}, {255,0,0}, {255,0,0}, {255,0,0},
        {255,0,0}, {255,0,0}, {255,0,0}, {255,0,0}, {255,0,0}, {255,0,0}, {255,0,0}, {255,0,0},
        {255,0,0}, {255,2,0}, {255,4,0}, {255,6,0}, {255,8,0}, {255,10,0}, {255,12,0}, {255,14,0},
        {255,16,0}, {255,18,0}, {255,20,0}, {255,22,0}, {255,24,0}, {255,26,0}, {255,28,0}, {255,30,0},
        {255,32,0}, {255,34,0}, {255,36,0}, {255,38,0}, {255,40,0}, {255,42,0}, {255,44,0}, {255,46,0},
        {255,48,0}, {255,50,0}, {255,52,0}, {255,54,0}, {255,56,0}, {255,58,0}, {255,60,0}, {255,62,0},
        {255,64,0}, {255,66,0}, {255,68,0}, {255,70,0}, {255,72,0}, {255,74,0}, {255,76,0}, {255,78,0},
        {255,80,0}, {255,82,0}, {255,84,0}, {255,86,0}, {255,88,0}, {255,90,0}, {255,92,0}, {255,94,0},
        {255,96,0}, {255,98,0}, {255,100,0}, {255,102,0}, {255,104,0}, {255,106,0}, {255,108,0}, {255,110,0},
        {255,112,0}, {255,114,0}, {255,116,0}, {255,118,0}, {255,120,0}, {255,122,0}, {255,124,0}, {255,126,0},
        {255,128,0}, {255,130,0}, {255,132,0}, {255,134,0}, {255,136,0}, {255,138,0}, {255,140,0}, {255,142,0},
        {255,144,0}, {255,146,0}, {255,148,0}, {255,150,0}, {255,152,0}, {255,154,0}, {255,156,0}, {255,158,0},
        {255,160,0}, {255,162,0}, {255,164,0}, {255,166,0}, {255,168,0}, {255,170,0}, {255,172,0}, {255,174,0},
        {255,176,0}, {255,178,0}, {255,180,0}, {255,182,0}, {255,184,0}, {255,186,0}, {255,188,0}, {255,190,0},
        {255,192,0}, {255,194,0}, {255,196,0}, {255,198,0}, {255,200,0}, {255,202,0}, {255,204,0}, {255,206,0},
        {255,208,0}, {255,210,0}, {255,212,0}, {255,214,0}, {255,216,0}, {255,218,0}, {255,220,0}, {255,222,0},
        {255,224,0}, {255,226,0}, {255,228,0}, {255,230,0}, {255,232,0}, {255,234,0}, {255,236,0}, {255,238,0},
        {255,240,0}, {255,242,4}, {255,244,8}, {255,246,12}, {255,248,16}, {255,250,20}, {255,252,24}, {255,254,28},
        {255,255,32}, {255,255,36}, {255,255,40}, {255,255,44}, {255,255,48}, {255,255,52}, {255,255,56}, {255,255,60},
        {255,255,64}, {255,255,68}, {255,255,72}, {255,255,76}, {255,255,80}, {255,255,84}, {255,255,88}, {255,255,92},
        {255,255,96}, {255,255,100}, {255,255,104}, {255,255,108}, {255,255,112}, {255,255,116}, {255,255,120}, {255,255,124},
        {255,255,128}, {255,255,132}, {255,255,136}, {255,255,140}, {255,255,144}, {255,255,148}, {255,255,152}, {255,255,156},
        {255,255,160}, {255,255,164}, {255,255,168}, {255,255,172}, {255,255,176}, {255,255,180}, {255,255,184}, {255,255,188},
        {255,255,192}, {255,255,196}, {255,255,200}, {255,255,204}, {255,255,208}, {255,255,212}, {255,255,216}, {255,255,220}
    };
};

} // namespace mm
